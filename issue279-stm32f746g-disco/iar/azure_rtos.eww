<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sample_threadx\sample_threadx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\stm32f7xx_library\stm32f7xx_library.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\threadx\threadx.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>build_all</name>
            <member>
                <project>threadx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>filex</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>guix</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>usbx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>netxduo</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>stm32f7xx_library</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_filex_ram_disk</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_filex_sd_card</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_guix_home_automation</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_guix_medical</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_guix_speedometer</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_netx_duo_iperf</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_netx_duo_ping</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_threadx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_usbx_device_mass_storage</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_usbx_host_mass_storage</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_azure_iot_embedded_sdk</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_azure_iot_embedded_sdk_pnp</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_pnp_temperature_controller</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
