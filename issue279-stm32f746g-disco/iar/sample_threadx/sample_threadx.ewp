# IAR project sample_threadx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: STM32F746xx
  ICCARM.CCIncludePath2: ..\threadx\common\inc; ..\threadx\ports\cortex_m7\iar\inc; ..\stm32f7xx_library; ..\common_hardware_code
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sample_threadx.out
  ILINK.IlinkIcfFile: ..\common_hardware_code\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../common_hardware_code/: common_hardware_code.c startup_stm32f746xx.s tx_initialize_low_level.s
    ./: sample_threadx.c
    ../stm32f7xx_library/Debug/Exe/: stm32f7xx_library.a
    ../threadx/Debug/Exe/: threadx.a
