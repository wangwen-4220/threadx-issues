# IAR project stm32f7xx_library.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: STM32F746xx
  ICCARM.CCIncludePath2: ; Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm32f4xx_library.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: ampire480272.h arm_common_tables.h arm_math.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h ft5336.c ft5336.h lcd.h n25q128a.h rk043fn48h.h stm32746g_discovery.c stm32746g_discovery.h stm32746g_discovery_eeprom.c stm32746g_discovery_eeprom.h stm32746g_discovery_lcd.c stm32746g_discovery_lcd.h stm32746g_discovery_qspi.c stm32746g_discovery_qspi.h stm32746g_discovery_sd.c stm32746g_discovery_sd.h stm32746g_discovery_sdram.c stm32746g_discovery_sdram.h stm32746g_discovery_ts.c stm32746g_discovery_ts.h stm32_hal_legacy.h stm32f746xx.h stm32f7xx.h stm32f7xx_hal.c stm32f7xx_hal.h stm32f7xx_hal_adc.c stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.c stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.c stm32f7xx_hal_can.h stm32f7xx_hal_cec.c stm32f7xx_hal_cec.h stm32f7xx_hal_conf.h stm32f7xx_hal_conf_template.h stm32f7xx_hal_cortex.c stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.c stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.c stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.c stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dma.c stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma_ex.h stm32f7xx_hal_eth.c stm32f7xx_hal_eth.h stm32f7xx_hal_flash.c stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.c stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.c stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.c stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.c stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.c stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.c stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.c stm32f7xx_hal_iwdg.h stm32f7xx_hal_lptim.c stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc.h stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nand.h stm32f7xx_hal_nor.c stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.c stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.c stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.c stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.c stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.c stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.c stm32f7xx_hal_spi.h stm32f7xx_hal_sram.c stm32f7xx_hal_sram.h stm32f7xx_hal_tim.c stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.c stm32f7xx_hal_tim_ex.h stm32f7xx_hal_timebase_tim_template.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.c stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.c stm32f7xx_hal_wwdg.h stm32f7xx_ll_fmc.c stm32f7xx_ll_fmc.h stm32f7xx_ll_sdmmc.c stm32f7xx_ll_sdmmc.h stm32f7xx_ll_usb.c stm32f7xx_ll_usb.h system_stm32f7xx.c system_stm32f7xx.h ts.h
